# Keil uVision project lion_bot.uvprojx, settings and files
target lion_bot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lion_bot
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\application\user;..\core\common;..\core\communicate;..\core\control;..\driver\can;..\driver\FeedMotor;..\driver\others;..\driver\timer;..\driver\usart;..\library\lion;..\library\rm;..\library\st;..\application\configureation
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group application/user
    ../application/user/: main.c stm32f4xx_it.c stm32f4xx_conf.h
  group application/configureation
    ../application/configureation/: configureation.c
  group core/common
    ../core/common/: supervisor_task.c control_task.c fsm_task.c
  group core/communicate
    ../core/communicate/: can_task.c rc_task.c js_task.c tx2_task.c imu_task.c
  group core/control
    ../core/control/: gimbal_task.c chassis_task.c shoot_task.c
  group driver/can
    ../driver/can/: can1.c can2.c
  group driver/usart
    ../driver/usart/: usart1.c usart2.c usart3.c usart6.c uart4.c
  group driver/timer
    ../driver/timer/: pwm.c timer.c
  group driver/others
    ../driver/others/: bsp.c laser.c border_measure.c
  group library/lion
    ../library/lion/: common.c crc_protocal.c
  group library/rm
    ../library/rm/: pid.c ramp.c
  group library/st
    ../library/st/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c startup_stm32f4xx.s
software components: CMSIS:CORE 3.20.0
